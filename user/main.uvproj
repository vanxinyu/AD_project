# Keil uVision project main.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F373RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: main
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, USE_STM32373C_EVAL, STM32F37X
  c include: ..\user;..\stm32f3;..\lib\inc;..\lib\src;..\ff\FatFs_vR0.08a;..\ff\FatFs_vR0.08a\option;..\ff;..\drive
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_stm32f37x.s
    ../stm32f3/: system_stm32f37x.c stm32f37x_it.c
  group user
    ./: main.c
  group drive
    ../drive/: w25x16.c fatapp.c ili9328.c sd.c uart.c sdadc.c systick.c rtc.c
  group lib
    ../lib/src/: stm32f37x_spi.c stm32f37x_gpio.c stm32f37x_rcc.c stm32f37x_usart.c stm32f37x_exti.c stm32f37x_misc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_pwr.c
  group ff
    ../ff/FatFs_vR0.08a/: diskio.c ff.c
    ../ff/FatFs_vR0.08a/option/: cc936.c
